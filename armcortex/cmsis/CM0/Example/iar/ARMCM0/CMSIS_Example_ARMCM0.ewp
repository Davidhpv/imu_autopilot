# IAR project CMSIS_Example_ARMCM0.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/ARM/ARMCM0
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: CMSIS_Example_ARMCM0.hex
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: Abstract.txt main_ARMCM0.c startup_armcm0.s system_armcm0.c
    ../../../CoreSupport/: core_cm0.c
