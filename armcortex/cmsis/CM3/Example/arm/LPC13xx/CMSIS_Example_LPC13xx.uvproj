# Keil uVision project CMSIS_Example_LPC13xx.uvproj, settings and files
target MCB1000 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c include: ../../../CoreSupport; ../../../DeviceSupport/NXP/LPC13xx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group CMSIS files
    ../../../CoreSupport/: core_cm3.c
    ./: startup_LPC13xx.s system_LPC13xx.c
  group Source files
    ./: main_LPC13xx.c
  group Documentation
    ./: Abstract.txt
