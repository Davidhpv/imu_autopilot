# IAR project CMSIS_Example_LM3S6965.ewp, settings and files
configuration EK-LM3S6965 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/TI/LM3S
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CMSIS_Test_LM3S6965.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_LM3S6965.c startup_LM3S.s system_LM3S.c
    ../../../CoreSupport/: core_cm3.c
