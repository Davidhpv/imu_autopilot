# IAR project CMSIS_Example_TMPM330.ewp, settings and files
configuration MCBTMPM330 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TMPM330FxFG Toshiba TMPM330FxFG
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/Toshiba/TMPM330
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CMSIS_Test_TMPM330.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_TMPM330.c startup_TMPM330.s system_TMPM330.c
    ../../../CoreSupport/: core_cm3.c
