# IAR project CMSIS_Example_LPC13xx.ewp, settings and files
configuration MCB1000 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/NXP/LPC13xx
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CMSIS_Example_LPC13xx.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_LPC13xx.c startup_LPC13xx.s system_LPC13xx.c
    ../../../CoreSupport/: core_cm3.c
