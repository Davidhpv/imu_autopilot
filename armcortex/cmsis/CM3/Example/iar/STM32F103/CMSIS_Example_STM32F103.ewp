# IAR project CMSIS_Example_STM32F103.ewp, settings and files
configuration MCBSTM32E (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: STM32F10X_HD; DATA_IN_ExtSRAM
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/ST/STM32F10x
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CMSIS_Test_STM32F103.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_STM32F103.c startup_stm32f10x_hd.s system_stm32f10x.c
    ../../../CoreSupport/: core_cm3.c
