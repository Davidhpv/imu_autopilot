<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CMSIS_Example_AT91SAM3U.ewp</path>
  </project>
  <batchBuild/>
</workspace>


