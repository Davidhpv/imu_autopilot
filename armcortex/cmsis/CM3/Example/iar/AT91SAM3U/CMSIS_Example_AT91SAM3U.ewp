# IAR project CMSIS_Example_AT91SAM3U.ewp, settings and files
configuration AT91SAM3U-EK (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/Atmel/AT91SAM3U
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_AT91SAM3U.c startup_SAM3U.s system_SAM3U.c
    ../../../CoreSupport/: core_cm3.c
